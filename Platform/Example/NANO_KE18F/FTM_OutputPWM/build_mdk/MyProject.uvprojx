# Keil uVision project MyProject.uvprojx, settings and files
target MyProject (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKE18F512xxx16 Freescale
  pack: Keil.Kinetis_KExx_DFP.1.4.0-dev1
  cpu: IROM(0x00000000,0x00080000) IROM2(0x10000000,0x00010000) IRAM(0x1FFF8000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MyProject
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..;..\..\..\..\Board\NANO_KE18F;..\..\..\..\CMSIS\Include;..\..\..\..\CMSIS\Devices\MKE18F16;..\..\..\..\Driver;..\..\..\..\..\Component\midware\cmd_shell\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  scatter file: ..\..\..\..\CMSIS\Devices\MKE18F16\arm\MKE18F512xxx16_flash.scf
  group Application
    ../: app_inc.h main.c cmd_shell_table.c
  group Board
    ../../../../Board/NANO_KE18F/: bsp_config.c bsp_config.h
  group Driver
    ../../../../Driver/: hal_lpuart.c hal_ftm.c hal_gpio.c
  group CMSIS
    ../../../../CMSIS/Devices/MKE18F16/arm/: startup_MKE18F16.s
    ../../../../CMSIS/Devices/MKE18F16/: system_MKE18F16.c
  group cmd_shell
    ../../../../../Component/midware/cmd_shell/source/: cmd_shell.c cmd_shell.h
