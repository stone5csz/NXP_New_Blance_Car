# Keil uVision project MyProject.uvprojx, settings and files
target MyProject (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MKE18F512xxx16 Freescale
  pack: Keil.Kinetis_KExx_DFP.1.4.0
  cpu: IROM(0x00000000,0x00080000) IROM2(0x10000000,0x00010000) IRAM(0x1FFF8000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MyProject
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..;..\..\..\..\Platform\Board\NANO_KE18F;..\..\..\..\Platform\CMSIS\Include;..\..\..\..\Platform\CMSIS\Devices\MKE18F16;..\..\..\..\Platform\Driver;..\..\..\..\Platform\..\Component\midware\cmd_shell\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  scatter file: ..\..\..\..\Platform\CMSIS\Devices\MKE18F16\arm\MKE18F512xxx16_flash.scf
  group Application
    ../: app_inc.h main.c pid.c balance_sense.c movement_control.c time.c
  group Board
    ../../../../Platform/Board/NANO_KE18F/: bsp_config.c bsp_config.h bsp_motor.c bsp_motor.h bsp_motor_config.c bsp_motor_config.h bsp_eidetect_config.c bsp_eidetect.c bsp_rf.c bsp_rf_config.c
  group Driver
    ../../../../Platform/Driver/: hal_lpuart.c hal_ftm.c hal_gpio.c hal_lpit.c hal_edma.c hal_lpi2c.c fsl_lpspi.c
  group CMSIS
    ../../../../Platform/CMSIS/Devices/MKE18F16/arm/: startup_MKE18F16.s
    ../../../../Platform/CMSIS/Devices/MKE18F16/: system_MKE18F16.c
